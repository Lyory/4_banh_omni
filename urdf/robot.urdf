Commit message: update1

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot, 10 links, 9 joints
Joints:
- joint l2: limit lower=-0.05 upper=0.7 effort=100.0 velocity=1.0 -> lower=-0.05 upper=0.07 effort=100.0 velocity=1.0
